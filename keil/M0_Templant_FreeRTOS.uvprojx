# Keil uVision project M0_Templant_FreeRTOS.uvprojx, settings and files
target M0_Templant_FreeRTOS (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: M0_Templant_FreeRTOS +hex
  BeforeMake: cmd.exe /C call "$Psyscfg.bat" "$P" main.syscfg
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;../Component;D:\Ti\mspm0_sdk_2_04_00_06\source\third_party\CMSIS\Core\Include;D:\Ti\mspm0_sdk_2_04_00_06\source;.\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM0;.\FreeRTOS\portable\MemMang;..\Component\led;..\Component\oled
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\Ti\mspm0_sdk_2_04_00_06\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: main.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c
    ./: startup_mspm0g350x_uvision.s
  group Component/led
    ../Component/led/: led.c led.h key.c key.h
  group Component/oled
    ../Component/oled/: oled.c oled.h oledfont.h bmp.h
  group Component/tb6612
    ../Component/tb6612/: tb6612.c tb6612.h
  group Component/encoder
    ../Component/encoder/: encoder.c encoder.h
  group Component/pid
    ../Component/pid/: pid.c pid.h
  group Component/control
    ../Component/control/: speed_loop_core.c speed_loop_core.h
  group Component/common
    ../Component/common/: util.h
  group Component/UART
    ../Component/UART/: uart0.c uart0.h
  group Component/service
    ../Component/service/: speed_service.c speed_service.h
  group New Group
    ../Component/mpu6050/: IIC.c IIC.h mpu6050.c mpu6050.h
